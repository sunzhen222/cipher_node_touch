# Keil uVision project cipher_node_touch.uvprojx, settings and files
target firmware (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08020000,0x000E0000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: cipher_node_touch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE,USE_HAL_DRIVER,STM32F405xx
  c misc: --diag_suppress=1 --diag_suppress=188 --diag_suppress=111
  c include: ..\src\core;..\src\application;..\src\usb_device\App;..\src\usb_device\Target;..\src\usb_device\STM32_USB_Device_Library\Core\Inc;..\src\usb_device\STM32_USB_Device_Library\Class;..\src\usb_device\STM32_USB_Device_Library\Class\MSC\Inc;..\src\usb_device\STM32_USB_Device_Library\Class\CDC\Inc;..\src\st_libs\STM32F4xx_HAL_Driver\Inc;..\src\st_libs\STM32F4xx_HAL_Driver\Inc\Legacy;..\src\FreeRTOS;..\src\FreeRTOS\Source;..\src\FreeRTOS\Source\include;..\src\FreeRTOS\CMSIS_RTOS_V2;..\src\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\src\driver;..\src\utils;..\src\tasks;..\src\test;..\src\msg;..\src\cm_backtrace;..\src\fatfs;..\src\components;..\src\components\checksum;..\src\components\cjson;..\src\porting;..\src\wireless;..\src\wifi;..\src\ui\framework;..\src\ui\images;..\src\ui\pages;..\src\ui\themes;..\src\ui\widgets;..\third\lvgl;..\third\ctaes;..\src\st_libs\CMSIS\Device\ST\STM32F4xx\Include;..\src\st_libs\CMSIS\Include
  asm include: .
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group mdk
    ./: startup_stm32f405xx.s
  group application
    ../src/application/: battery.c draw_on_lcd.c lock_screen.c lora_chat.c mqtt_chat.c save_error.c sht30_app.c snapshot.c
  group cm_backtrace
    ../src/cm_backtrace/: cm_backtrace.c
    ../src/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group components
    ../src/components/checksum/: crc.c md5.c sha256.c
    ../src/components/cjson/: cJSON.c
  group core
    ../src/core/: device_settings.c hardware_version.c main.c software_version.c startup.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c
  group driver
    ../src/driver/: drv_adc.c drv_button.c drv_dma.c drv_gpio.c drv_i2c.c drv_i2c_io.c drv_lcd.c drv_power_switch.c drv_sht30.c drv_spi.c drv_sys.c drv_timer.c drv_touch.c drv_trng.c drv_uart.c drv_w25qxx.c
  group driver/llcc68
    ../src/driver/llcc68/: driver_llcc68.c driver_llcc68_interface.c
  group fatfs
    ../src/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS
    ../src/FreeRTOS/: rtos_expand.c
    ../src/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../src/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../src/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../src/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group msg
    ../src/msg/: general_msg.c user_msg.c
  group porting
    ../src/porting/: lv_mem_core_custom.c lv_port_disp.c lv_port_indev.c
  group STM32F4xx_HAL_Driver
    ../src/st_libs/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c
  group tasks
    ../src/tasks/: background_task.c cmd_task.c startup_task.c test_task.c touch_task.c ui_task.c usb_task.c wireless_task.c
  group test
    ../src/test/: processor_usage.c test_cmd.c wifi_test.c
  group ui/framework
    ../src/ui/framework/: navigation_bar.c page.c status_bar.c ui_msg.c
  group ui/images
    ../src/ui/images/: cipher_node_touch_logo.c img_back.c img_battery.c img_lock.c img_lora_signal.c img_settings.c img_tile_left.c img_tile_right.c img_wifi_disabled.c img_wifi_signal.c img_wifi_signal_weak1.c img_wifi_signal_weak2.c img_wifi_signal_weak3.c
  group ui/pages
    ../src/ui/pages/: about_page.c home_page.c lcd_settings_page.c lora_chat_page.c lora_chat_settings_page.c mqtt_chat_page.c mqtt_chat_settings_page.c snake_page.c system_page.c touch_test_page.c wifi_page.c
  group ui/themes
    ../src/ui/themes/: lv_theme_pocket.c
  group ui/widgets
    ../src/ui/widgets/: confirm_win.c input_number.c input_text.c loading_spinner.c select_number.c tile_dots.c user_menu.c widgets_line.c
  group usb_device/App
    ../src/usb_device/App/: usb_device.c usbd_cdc_if.c usbd_desc.c usbd_storage_if.c
  group usb_device/STM32_USB_Device_Library
    ../src/usb_device/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../src/usb_device/STM32_USB_Device_Library/Class/: usbd_composite.c
    ../src/usb_device/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../src/usb_device/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group usb_device/Target
    ../src/usb_device/Target/: usbd_conf.c
  group utils
    ../src/utils/: ring_buffer.c user_assert.c user_delay.c user_fs.c user_memory.c user_utils.c
  group wifi
    ../src/wifi/: at_command.c mqtt.c wifi_connect.c wifi_search.c
  group wireless
    ../src/wireless/: command_lora_chat.c lora.c protocol_codec.c protocol_parse.c
  group third/ctaes
    ../third/ctaes/: ctaes.c
  group third/lvgl
    ..//third/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ..//third/lvgl/src/display/: lv_display.c
    ..//third/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ..//third/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ..//third/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ..//third/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ..//third/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ..//third/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ..//third/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ..//third/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ..//third/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ..//third/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ..//third/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ..//third/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ..//third/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ..//third/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ..//third/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ..//third/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ..//third/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ..//third/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ..//third/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ..//third/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ..//third/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ..//third/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ..//third/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ..//third/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ..//third/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ..//third/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ..//third/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ..//third/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ..//third/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ..//third/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ..//third/lvgl/src/drivers/evdev/: lv_evdev.c
    ..//third/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ..//third/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ..//third/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ..//third/lvgl/src/drivers/opengles/glad/src/: egl.c gles2.c
    ..//third/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ..//third/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ..//third/lvgl/src/drivers/qnx/: lv_qnx.c
    ..//third/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ..//third/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ..//third/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ..//third/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ..//third/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ..//third/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ..//third/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ..//third/lvgl/src/layouts/flex/: lv_flex.c
    ..//third/lvgl/src/layouts/grid/: lv_grid.c
    ..//third/lvgl/src/layouts/: lv_layout.c
    ..//third/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ..//third/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ..//third/lvgl/src/libs/bmp/: lv_bmp.c
    ..//third/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ..//third/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ..//third/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ..//third/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ..//third/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ..//third/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ..//third/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ..//third/lvgl/src/libs/gif/: lv_gif.c
    ..//third/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ..//third/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ..//third/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ..//third/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ..//third/lvgl/src/libs/libpng/: lv_libpng.c
    ..//third/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ..//third/lvgl/src/libs/lz4/: lz4.c
    ..//third/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ..//third/lvgl/src/libs/rle/: lv_rle.c
    ..//third/lvgl/src/libs/rlottie/: lv_rlottie.c
    ..//third/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ..//third/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ..//third/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ..//third/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ..//third/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ..//third/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ..//third/lvgl/src/: lv_init.c
    ..//third/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ..//third/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ..//third/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ..//third/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ..//third/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ..//third/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ..//third/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ..//third/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ..//third/lvgl/src/others/gridnav/: lv_gridnav.c
    ..//third/lvgl/src/others/ime/: lv_ime_pinyin.c
    ..//third/lvgl/src/others/imgfont/: lv_imgfont.c
    ..//third/lvgl/src/others/monkey/: lv_monkey.c
    ..//third/lvgl/src/others/observer/: lv_observer.c
    ..//third/lvgl/src/others/snapshot/: lv_snapshot.c
    ..//third/lvgl/src/others/sysmon/: lv_sysmon.c
    ..//third/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ..//third/lvgl/src/others/translation/: lv_translation.c
    ..//third/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ..//third/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ..//third/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ..//third/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ..//third/lvgl/src/stdlib/: lv_mem.c
    ..//third/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ..//third/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ..//third/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ..//third/lvgl/src/themes/default/: lv_theme_default.c
    ..//third/lvgl/src/themes/: lv_theme.c
    ..//third/lvgl/src/themes/mono/: lv_theme_mono.c
    ..//third/lvgl/src/themes/simple/: lv_theme_simple.c
    ..//third/lvgl/src/tick/: lv_tick.c
    ..//third/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ..//third/lvgl/src/widgets/animimage/: lv_animimage.c
    ..//third/lvgl/src/widgets/arc/: lv_arc.c
    ..//third/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ..//third/lvgl/src/widgets/bar/: lv_bar.c
    ..//third/lvgl/src/widgets/button/: lv_button.c
    ..//third/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ..//third/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ..//third/lvgl/src/widgets/canvas/: lv_canvas.c
    ..//third/lvgl/src/widgets/chart/: lv_chart.c
    ..//third/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ..//third/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ..//third/lvgl/src/widgets/image/: lv_image.c
    ..//third/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ..//third/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ..//third/lvgl/src/widgets/label/: lv_label.c
    ..//third/lvgl/src/widgets/led/: lv_led.c
    ..//third/lvgl/src/widgets/line/: lv_line.c
    ..//third/lvgl/src/widgets/list/: lv_list.c
    ..//third/lvgl/src/widgets/lottie/: lv_lottie.c
    ..//third/lvgl/src/widgets/menu/: lv_menu.c
    ..//third/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ..//third/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ..//third/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ..//third/lvgl/src/widgets/roller/: lv_roller.c
    ..//third/lvgl/src/widgets/scale/: lv_scale.c
    ..//third/lvgl/src/widgets/slider/: lv_slider.c
    ..//third/lvgl/src/widgets/span/: lv_span.c
    ..//third/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ..//third/lvgl/src/widgets/spinner/: lv_spinner.c
    ..//third/lvgl/src/widgets/switch/: lv_switch.c
    ..//third/lvgl/src/widgets/table/: lv_table.c
    ..//third/lvgl/src/widgets/tabview/: lv_tabview.c
    ..//third/lvgl/src/widgets/textarea/: lv_textarea.c
    ..//third/lvgl/src/widgets/tileview/: lv_tileview.c
    ..//third/lvgl/src/widgets/win/: lv_win.c
